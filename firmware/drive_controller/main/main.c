/* Original DASE7503 RC firmware. Only the board pin interface is referenced
 * from Yahboom hardware documentation; no prior student control code is used.
 * No boot motion and no servo pulse is generated by this initial wheel build.
 */
#include <stdio.h>
#include <string.h>
#include "driver/gpio.h"
#include "driver/ledc.h"
#include "driver/mcpwm_prelude.h"
#include "driver/pulse_cnt.h"
#include "driver/uart.h"
#include "hal/gpio_ll.h"
#include "esp_system.h"
#include "esp_rom_sys.h"
#include "esp_timer.h"
#include "esp_adc/adc_oneshot.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include <rcl/rcl.h>
#include <rclc/rclc.h>
#include <rclc/executor.h>
#include <rmw_microros/rmw_microros.h>
#include <std_msgs/msg/bool.h>
#include <std_msgs/msg/int32_multi_array.h>
#include <std_msgs/msg/int32.h>
#include <std_msgs/msg/string.h>
#include "guard.h"

static const int motor_pins[4][2] = {{4,5},{15,16},{9,10},{13,14}};
static const int encoder_pins[4][2] = {{6,7},{47,48},{11,12},{1,2}};
static pcnt_unit_handle_t encoders[4];
static portMUX_TYPE mux = portMUX_INITIALIZER_UNLOCKED;
static drive_guard_t guard;
static int applied[4];
static rcl_publisher_t status_pub;
static std_msgs__msg__Int32MultiArray wheel_msg;
static std_msgs__msg__Bool arm_msg;
static int32_t wheel_storage[4];
static std_msgs__msg__String status_msg;
static char status_storage[512];
static std_msgs__msg__Int32 servo_msg;
static mcpwm_cmpr_handle_t servo_comparator;
static mcpwm_gen_handle_t servo_generator;
static int servo_pulse;
static int64_t lift_until;
static int64_t servo_probe_until;
static bool servo_active;
static unsigned servo_edges,servo_requests;
static int64_t servo_rise_us;
static int servo_high_us;
static adc_oneshot_unit_handle_t battery_adc;
static int64_t watchdog_command_us,watchdog_stop_us,watchdog_settled_us;
static int watchdog_encoders[4];

static void servo_edge(void *arg) {
    int64_t now=esp_timer_get_time();
    int high=gpio_get_level(21);
    portENTER_CRITICAL_ISR(&mux);
    if(high)servo_rise_us=now;
    else if(servo_rise_us) {
        int width=(int)(now-servo_rise_us);
        if(width>=50 && width<=2350) {servo_edges++;servo_high_us=width;}
        servo_rise_us=0;
    }
    portEXIT_CRITICAL_ISR(&mux);
}

static void init_hardware(void) {
    /* Eight independent LEDC outputs: signed duty is defined per connector,
       and physical forward direction is calibrated on the assembled vehicle. */
    ledc_timer_config_t timer = {.speed_mode=LEDC_LOW_SPEED_MODE,
        .duty_resolution=LEDC_TIMER_10_BIT,.timer_num=LEDC_TIMER_0,
        .freq_hz=25000,.clk_cfg=LEDC_AUTO_CLK};
    ESP_ERROR_CHECK(ledc_timer_config(&timer));
    for (int i=0; i<4; i++) {
        for (int j=0; j<2; j++) {
            gpio_set_direction(motor_pins[i][j], GPIO_MODE_OUTPUT);
            gpio_set_level(motor_pins[i][j], 0);
            ledc_channel_config_t channel = {.gpio_num=motor_pins[i][j],
                .speed_mode=LEDC_LOW_SPEED_MODE,.channel=2*i+j,
                .timer_sel=LEDC_TIMER_0,.duty=0,.hpoint=0};
            ESP_ERROR_CHECK(ledc_channel_config(&channel));
            /* IDF 5.2 has no public input-only enable API. Do not call
               gpio_set_direction here: it would replace the LEDC route. */
            gpio_ll_input_enable(&GPIO, motor_pins[i][j]);
        }
        pcnt_unit_config_t unit = {.low_limit=-30000,.high_limit=30000,.flags.accum_count=true};
        ESP_ERROR_CHECK(pcnt_new_unit(&unit, &encoders[i]));
        pcnt_glitch_filter_config_t filter = {.max_glitch_ns=1000};
        ESP_ERROR_CHECK(pcnt_unit_set_glitch_filter(encoders[i], &filter));
        for (int j=0; j<2; j++) {
            gpio_set_pull_mode(encoder_pins[i][j], GPIO_PULLUP_ONLY);
            pcnt_chan_config_t config = {.edge_gpio_num=encoder_pins[i][j],
                .level_gpio_num=encoder_pins[i][1-j]};
            pcnt_channel_handle_t channel;
            ESP_ERROR_CHECK(pcnt_new_channel(encoders[i], &config, &channel));
            ESP_ERROR_CHECK(pcnt_channel_set_edge_action(channel,
                j ? PCNT_CHANNEL_EDGE_ACTION_INCREASE : PCNT_CHANNEL_EDGE_ACTION_DECREASE,
                j ? PCNT_CHANNEL_EDGE_ACTION_DECREASE : PCNT_CHANNEL_EDGE_ACTION_INCREASE));
            ESP_ERROR_CHECK(pcnt_channel_set_level_action(channel,
                PCNT_CHANNEL_LEVEL_ACTION_KEEP,PCNT_CHANNEL_LEVEL_ACTION_INVERSE));
        }
        ESP_ERROR_CHECK(pcnt_unit_add_watch_point(encoders[i],30000));
        ESP_ERROR_CHECK(pcnt_unit_add_watch_point(encoders[i],-30000));
        ESP_ERROR_CHECK(pcnt_unit_enable(encoders[i]));
        ESP_ERROR_CHECK(pcnt_unit_clear_count(encoders[i]));
        ESP_ERROR_CHECK(pcnt_unit_start(encoders[i]));
    }
    adc_oneshot_unit_init_cfg_t adc_config = {.unit_id=ADC_UNIT_1};
    ESP_ERROR_CHECK(adc_oneshot_new_unit(&adc_config, &battery_adc));
    adc_oneshot_chan_cfg_t battery_config = {.atten=ADC_ATTEN_DB_12,.bitwidth=ADC_BITWIDTH_DEFAULT};
    ESP_ERROR_CHECK(adc_oneshot_config_channel(battery_adc,ADC_CHANNEL_2,&battery_config));
}

static void motor_task(void *arg) {
    int prior_counts[4]={0};
    int64_t last_encoder_change_us=0;
    bool waiting_for_settle=false;
    while (true) {
        int target[4];
        bool new_timeout=false;
        portENTER_CRITICAL(&mux);
        guard_tick(&guard, esp_timer_get_time());
        if(guard.timed_out && guard.command_us!=watchdog_command_us) {
            new_timeout=true;
            watchdog_command_us=guard.command_us;
            watchdog_stop_us=0;
            watchdog_settled_us=0;
        }
        memcpy(target, guard.duty, sizeof(target));
        portEXIT_CRITICAL(&mux);
        for (int i=0; i<4; i++) {
            /* Always turn both legs off before applying a direction change. */
            if (target[i] != applied[i]) {
                for (int j=0;j<2;j++) {
                    ESP_ERROR_CHECK(ledc_set_duty(LEDC_LOW_SPEED_MODE,2*i+j,0));
                    ESP_ERROR_CHECK(ledc_update_duty(LEDC_LOW_SPEED_MODE,2*i+j));
                }
                int leg = target[i] > 0 ? 1 : 0;
                int magnitude = target[i] < 0 ? -target[i] : target[i];
                ESP_ERROR_CHECK(ledc_set_duty(LEDC_LOW_SPEED_MODE,2*i+leg,magnitude*1023/1000));
                ESP_ERROR_CHECK(ledc_update_duty(LEDC_LOW_SPEED_MODE,2*i+leg));
                portENTER_CRITICAL(&mux);
                applied[i] = target[i];
                portEXIT_CRITICAL(&mux);
            }
        }
        if(new_timeout) {
            for(int i=0;i<4;i++)pcnt_unit_get_count(encoders[i],&prior_counts[i]);
            last_encoder_change_us=esp_timer_get_time();
            portENTER_CRITICAL(&mux);
            watchdog_stop_us=last_encoder_change_us;
            portEXIT_CRITICAL(&mux);
            waiting_for_settle=true;
        }
        if(waiting_for_settle) {
            int counts[4];
            for(int i=0;i<4;i++)pcnt_unit_get_count(encoders[i],&counts[i]);
            int64_t now=esp_timer_get_time();
            if(memcmp(counts,prior_counts,sizeof(counts))!=0) {
                memcpy(prior_counts,counts,sizeof(counts));
                last_encoder_change_us=now;
            } else if(now-last_encoder_change_us>=200000) {
                portENTER_CRITICAL(&mux);
                watchdog_settled_us=now;
                memcpy(watchdog_encoders,counts,sizeof(counts));
                portEXIT_CRITICAL(&mux);
                waiting_for_settle=false;
            }
            if(now-last_encoder_change_us>5000000)waiting_for_settle=false;
        }
        portENTER_CRITICAL(&mux);
        bool probe_expired=servo_probe_until && esp_timer_get_time()>=servo_probe_until;
        portEXIT_CRITICAL(&mux);
        if(probe_expired) {
            ESP_ERROR_CHECK(mcpwm_generator_set_force_level(servo_generator,0,true));
            portENTER_CRITICAL(&mux);
            servo_active=false;
            servo_probe_until=0;
            portEXIT_CRITICAL(&mux);
        }
        vTaskDelay(pdMS_TO_TICKS(5));
    }
}

static void wheel_callback(const void *input) {
    const std_msgs__msg__Int32MultiArray *msg=input;
    portENTER_CRITICAL(&mux);
    if (msg->data.size != 4) {
        guard_stop(&guard);
        guard.neutral_us = 0;
    } else {
        int values[4];
        for (int i=0;i<4;i++) values[i]=msg->data.data[i];
        int64_t now=esp_timer_get_time();
        bool moving=false;
        for(int i=0;i<4;i++) moving=moving || values[i]!=0;
        if(moving && now<lift_until) guard_stop(&guard);
        else guard_command(&guard, values, now);
    }
    portEXIT_CRITICAL(&mux);
}

static void servo_callback(const void *input) {
    int pulse=((const std_msgs__msg__Int32 *)input)->data;
    /* Negative pulse requests are unloaded calibration probes: send the
       absolute pulse width for at most 120ms (40ms below 400us), then
       independently force the pin low.
       This limits signal duration, not servo torque or angular travel. */
    bool probe=pulse<=-150 && pulse>=-2300;
    if(probe)pulse=-pulse;
    if(pulse<150 || pulse>2300)return;
    portENTER_CRITICAL(&mux);
    bool stopped=servo_probe_until==0;
    for(int i=0;i<4;i++)stopped=stopped && applied[i]==0 && guard.duty[i]==0;
    if(stopped)lift_until=esp_timer_get_time()+2000000;
    portEXIT_CRITICAL(&mux);
    if(!stopped)return;
    if(!servo_comparator) {
        mcpwm_timer_handle_t timer;
        mcpwm_oper_handle_t oper;
        mcpwm_timer_config_t tc={.group_id=0,.clk_src=MCPWM_TIMER_CLK_SRC_DEFAULT,
            .resolution_hz=1000000,.period_ticks=20000,.count_mode=MCPWM_TIMER_COUNT_MODE_UP};
        ESP_ERROR_CHECK(mcpwm_new_timer(&tc,&timer));
        mcpwm_operator_config_t oc={.group_id=0};
        ESP_ERROR_CHECK(mcpwm_new_operator(&oc,&oper));
        ESP_ERROR_CHECK(mcpwm_operator_connect_timer(oper,timer));
        mcpwm_comparator_config_t cc={.flags.update_cmp_on_tez=true};
        ESP_ERROR_CHECK(mcpwm_new_comparator(oper,&cc,&servo_comparator));
        ESP_ERROR_CHECK(mcpwm_comparator_set_compare_value(servo_comparator,pulse));
        mcpwm_generator_config_t gc={.gen_gpio_num=21};
        ESP_ERROR_CHECK(mcpwm_new_generator(oper,&gc,&servo_generator));
        gpio_ll_input_enable(&GPIO,21);
        ESP_ERROR_CHECK(gpio_install_isr_service(0));
        ESP_ERROR_CHECK(gpio_set_intr_type(21,GPIO_INTR_ANYEDGE));
        ESP_ERROR_CHECK(gpio_isr_handler_add(21,servo_edge,NULL));
        ESP_ERROR_CHECK(mcpwm_generator_set_action_on_timer_event(servo_generator,
            MCPWM_GEN_TIMER_EVENT_ACTION(MCPWM_TIMER_DIRECTION_UP,MCPWM_TIMER_EVENT_EMPTY,MCPWM_GEN_ACTION_HIGH)));
        ESP_ERROR_CHECK(mcpwm_generator_set_action_on_compare_event(servo_generator,
            MCPWM_GEN_COMPARE_EVENT_ACTION(MCPWM_TIMER_DIRECTION_UP,servo_comparator,MCPWM_GEN_ACTION_LOW)));
        ESP_ERROR_CHECK(mcpwm_timer_enable(timer));
        ESP_ERROR_CHECK(mcpwm_timer_start_stop(timer,MCPWM_TIMER_START_NO_STOP));
    } else ESP_ERROR_CHECK(mcpwm_comparator_set_compare_value(servo_comparator,pulse));
    ESP_ERROR_CHECK(mcpwm_generator_set_force_level(servo_generator,-1,true));
    portENTER_CRITICAL(&mux);
    servo_pulse=pulse;
    servo_requests++;
    servo_active=true;
    servo_probe_until=probe ? esp_timer_get_time()+(pulse<400 ? 40000 : 120000) : 0;
    portEXIT_CRITICAL(&mux);
}

static void arm_callback(const void *input) {
    const std_msgs__msg__Bool *msg=input;
    portENTER_CRITICAL(&mux);
    if (msg->data) guard_arm(&guard,esp_timer_get_time());
    else { guard_stop(&guard); guard.neutral_us=0; }
    portEXIT_CRITICAL(&mux);
}

static void status_callback(rcl_timer_t *timer,int64_t last) {
    int counts[4], output[4]; bool armed,timeout;
    int battery_raw=-1,settled_counts[4],high_us,pulse;
    unsigned edges,requests; bool active;
    int64_t wd_command,wd_stop,wd_settled;
    if(adc_oneshot_read(battery_adc,ADC_CHANNEL_2,&battery_raw)!=ESP_OK)battery_raw=-1;
    for(int i=0;i<4;i++) pcnt_unit_get_count(encoders[i],&counts[i]);
    portENTER_CRITICAL(&mux);
    armed=guard.armed; timeout=guard.timed_out;
    memcpy(output,applied,sizeof(output));
    wd_command=watchdog_command_us;wd_stop=watchdog_stop_us;wd_settled=watchdog_settled_us;
    memcpy(settled_counts,watchdog_encoders,sizeof(settled_counts));
    high_us=servo_high_us;edges=servo_edges;requests=servo_requests;
    pulse=servo_pulse;active=servo_active;
    portEXIT_CRITICAL(&mux);
    status_msg.data.size=snprintf(status_storage,sizeof(status_storage),
        "{\"firmware\":\"dase-rc-0.9\",\"armed\":%s,\"watchdog_timeout\":%s,"
        "\"pwm\":[%d,%d,%d,%d],\"encoders\":[%d,%d,%d,%d],\"servo_us\":%d,\"board_us\":%lld,"
        "\"battery_adc_raw\":%d,"
        "\"wd_command_us\":%lld,\"wd_stop_us\":%lld,\"wd_settled_us\":%lld,\"wd_encoders\":[%d,%d,%d,%d],\"servo_active\":%s,\"servo_edges\":%u,\"servo_high_us\":%d,\"servo_requests\":%u}",
        armed?"true":"false",timeout?"true":"false",output[0],output[1],output[2],output[3],
        counts[0],counts[1],counts[2],counts[3],pulse,(long long)esp_timer_get_time(),
        battery_raw,(long long)wd_command,(long long)wd_stop,(long long)wd_settled,
        settled_counts[0],settled_counts[1],settled_counts[2],settled_counts[3],active?"true":"false",edges,high_us,requests);
    if(status_msg.data.size>=sizeof(status_storage))return;
    rcl_ret_t result = rcl_publish(&status_pub,&status_msg,NULL);
    (void)result;
}

static bool transport_open(struct uxrCustomTransport *transport) {
    uart_config_t config={.baud_rate=921600,.data_bits=UART_DATA_8_BITS,
        .parity=UART_PARITY_DISABLE,.stop_bits=UART_STOP_BITS_1,
        .flow_ctrl=UART_HW_FLOWCTRL_DISABLE,.source_clk=UART_SCLK_DEFAULT};
    if(uart_is_driver_installed(UART_NUM_0)) uart_driver_delete(UART_NUM_0);
    return uart_param_config(UART_NUM_0,&config)==ESP_OK &&
        uart_set_pin(UART_NUM_0,43,44,UART_PIN_NO_CHANGE,UART_PIN_NO_CHANGE)==ESP_OK &&
        uart_driver_install(UART_NUM_0,4096,0,0,NULL,0)==ESP_OK;
}
static bool transport_close(struct uxrCustomTransport *transport) {
    return uart_driver_delete(UART_NUM_0)==ESP_OK;
}
static size_t transport_write(struct uxrCustomTransport *transport,const uint8_t *buffer,size_t length,uint8_t *error) {
    int count=uart_write_bytes(UART_NUM_0,buffer,length);
    if(count<0) { *error=1; return 0; } return count;
}
static size_t transport_read(struct uxrCustomTransport *transport,uint8_t *buffer,size_t length,int timeout,uint8_t *error) {
    int count=uart_read_bytes(UART_NUM_0,buffer,length,pdMS_TO_TICKS(timeout));
    if(count<0) { *error=1; return 0; } return count;
}

static void checked(rcl_ret_t result) {
    if(result==RCL_RET_OK)return;
    portENTER_CRITICAL(&mux); guard_stop(&guard); portEXIT_CRITICAL(&mux);
    vTaskDelay(pdMS_TO_TICKS(1000)); esp_restart();
}

void app_main(void) {
    init_hardware();
    xTaskCreatePinnedToCore(motor_task,"motor_guard",4096,NULL,20,NULL,1);
    rmw_uros_set_custom_transport(true,NULL,transport_open,transport_close,transport_write,transport_read);
    while(rmw_uros_ping_agent(200,1)!=RMW_RET_OK) vTaskDelay(pdMS_TO_TICKS(300));
    rcl_allocator_t allocator=rcl_get_default_allocator();
    rcl_init_options_t options=rcl_get_zero_initialized_init_options();
    checked(rcl_init_options_init(&options,allocator));
    checked(rcl_init_options_set_domain_id(&options,20));
    rclc_support_t support;
    checked(rclc_support_init_with_options(&support,0,NULL,&options,&allocator));
    rcl_node_t node=rcl_get_zero_initialized_node();
    checked(rclc_node_init_default(&node,"dase_rc_controller","",&support));
    rcl_subscription_t wheels=rcl_get_zero_initialized_subscription();
    rcl_subscription_t arm=rcl_get_zero_initialized_subscription();
    rcl_subscription_t servo=rcl_get_zero_initialized_subscription();
    checked(rclc_subscription_init_best_effort(&wheels,&node,
        ROSIDL_GET_MSG_TYPE_SUPPORT(std_msgs,msg,Int32MultiArray),"wheel_pwm"));
    checked(rclc_subscription_init_best_effort(&arm,&node,
        ROSIDL_GET_MSG_TYPE_SUPPORT(std_msgs,msg,Bool),"drive_arm"));
    checked(rclc_subscription_init_default(&servo,&node,
        ROSIDL_GET_MSG_TYPE_SUPPORT(std_msgs,msg,Int32),"servo_s2_us"));
    checked(rclc_publisher_init_best_effort(&status_pub,&node,
        ROSIDL_GET_MSG_TYPE_SUPPORT(std_msgs,msg,String),"drive/status"));
    wheel_msg.data.data=wheel_storage;wheel_msg.data.size=0;wheel_msg.data.capacity=4;
    status_msg.data.data=status_storage;status_msg.data.capacity=sizeof(status_storage);
    rcl_timer_t timer=rcl_get_zero_initialized_timer();
    checked(rclc_timer_init_default2(&timer,&support,RCL_MS_TO_NS(50),status_callback,true));
    rclc_executor_t executor=rclc_executor_get_zero_initialized_executor();
    checked(rclc_executor_init(&executor,&support.context,4,&allocator));
    checked(rclc_executor_add_subscription(&executor,&wheels,&wheel_msg,wheel_callback,ON_NEW_DATA));
    checked(rclc_executor_add_subscription(&executor,&arm,&arm_msg,arm_callback,ON_NEW_DATA));
    checked(rclc_executor_add_subscription(&executor,&servo,&servo_msg,servo_callback,ON_NEW_DATA));
    checked(rclc_executor_add_timer(&executor,&timer));
    while(true) {
        rcl_ret_t result=rclc_executor_spin_some(&executor,RCL_MS_TO_NS(5));
        if(result!=RCL_RET_OK && result!=RCL_RET_TIMEOUT) checked(result);
        vTaskDelay(pdMS_TO_TICKS(1));
    }
}
